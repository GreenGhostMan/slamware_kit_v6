# IAR project base_ref.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VB ST STM32F103VB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USART_ENABLE_USART3; CONFIG_BREAKOUT_REV=3; USE_FRONT_IR_SENSORS; FEATURE_SET_V; _DEBUG
  ICCARM.CCDiagSuppress: pa050
  ICCARM.CCIncludePath2: src; ..\common_pub\inc; ..\drivers_pub\; ..\infra_pub\; ..\infra_pub\arch\st_fwlib\CMSIS\CM3\CoreSupport; ..\infra_pub\arch\st_fwlib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\infra_pub\arch\st_fwlib\STM32F10x_StdPeriph_Driver\inc; src; ..\infra_pub\arch\st_fwlib\CMSIS\CM3\CoreSupport; ..\infra_pub\arch\st_fwlib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\infra_pub\arch\st_fwlib\STM32F10x_StdPeriph_Driver\inc; ..\infra_pub\arch\st_fwlib\STM32_USB-FS-Device_Driver\inc; ..\infra_pub\arch\infra_stm32; ..\infra_pub\arch\infra_stm32\32f10x
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: base_ref.hex
  ILINK.IlinkOutputFile: base_ref.out
  ILINK.IlinkIcfFile: iar_ldscript\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USART_ENABLE_USART3; CONFIG_BREAKOUT_REV=3; USE_FRONT_IR_SENSORS; FEATURE_SET_V
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: src; ..\..\common\inc; ..\infra_pub; ..\infra_pub\arch\st_fwlib\CMSIS\CM3\CoreSupport; ..\infra_pub\arch\st_fwlib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\infra_pub\arch\st_fwlib\STM32F10x_StdPeriph_Driver\inc; ..\infra_pub\arch\infra_stm32; ..\infra_pub\arch\infra_stm32\32f10x
  ICCARM.CCOptLevel: 3
configuration Release_Rev4 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USART_ENABLE_USART3; CONFIG_BREAKOUT_REV=4; USE_FRONT_IR_SENSORS; FEATURE_SET_V
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
configuration Release_Rev6 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USART_ENABLE_USART3; CONFIG_BREAKOUT_REV=6; USE_FRONT_IR_SENSORS; FEATURE_SET_V
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  group BoardFuncs
    src/boardfunc/: stm32f10x_it.c stm32f10x_it.h
  group BoardFuncs/revision3
    src/boardfunc/revision3/: hwconf.c hwconf.h
  group BoardFuncs/revision4
    src/boardfunc/revision4/: hwconf.c hwconf.h
  group BoardFuncs/revision6
    src/boardfunc/revision6/: hwconf.c hwconf.h
  group common
    src/common/: common.h
  group drv
    src/drv/: battery.c battery.h beep.c beep.h bump.c bump.h ctrl_bus_cmd.h distir.c distir.h drv_ctrlbus.c drv_ctrlbus.h health_monitor.c health_monitor.h homeir.c homeir.h irdecoder.c irdecoder.h led.c led.h motor.c motor.h serial_channel.c serial_channel.h sonar.c sonar.h watchdog.c watchdog.h
  group Runtime/CMSIS/core
    ../infra_pub/arch/st_fwlib/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
  group Runtime/CMSIS/stm32f10x
    ../infra_pub/arch/st_fwlib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
    ../infra_pub/arch/st_fwlib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Runtime/FWLib/inc
    ../infra_pub/arch/st_fwlib/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group Runtime/FWLib/src
    ../infra_pub/arch/st_fwlib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Runtime/RP-STM32
    ../infra_pub/arch/infra_stm32/: rpstm32.h
  group Runtime/RP-STM32/32f10x
    ../infra_pub/arch/infra_stm32/32f10x/: boarddrv.c boardfunc.h softdelay.c softdelay.h usart.c usart.h
  group Runtime/RP-STM32/net
    ../infra_pub/arch/infra_stm32/net/: interchip.c interchip.h
  group Source
    src/: binary_config.c boarddef.h bump_monitor.c bump_monitor.h main.c request_handler.c stm32f10x_conf.h
  group utils
    src/utils/: filters.c filters.h util.c
